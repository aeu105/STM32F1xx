# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target STM32F103C8T6 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  c flags: Optim=5 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Application;..\Init;..\User;..\OS\Source;..\OS\Ports;..\OS\CPU;..\OS\CFG;..\OS\LIB;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../User/: stm32f10x_it.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Application
    ../Application/: application.c
  group Init
    ../Init/: bsp_init.c bsp_systick.c bsp_led.c bsp_usart.c
  group User
    ../User/: main.c
  group OS\Source
    ../OS/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group OS\CFG
    ../OS/Cfg/: os_app_hooks.c
  group OS\LIB
    ../OS/Lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group OS\Ports
    ../OS/Ports/: os_cpu_a.asm os_cpu_c.c
  group OS\CPU
    ../OS/Cpu/: cpu_a.asm cpu_c.c cpu_core.c
  group Doc
    ../Doc/: README.md
